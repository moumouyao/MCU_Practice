# Keil uVision project test.uvprojx, settings and files
target test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\user;..\user\api;..\lib\inc;..\System;..\startup;..\MQTT;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM3;..\Cjson
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/: stm32f10x_it.c system_stm32f10x.c main.c stm32f10x_conf.h stm32f10x.h FreeRTOSConfig.h
  group startup
    ../startup/: startup_stm32f10x_hd.s
  group api
    ../user/api/: buzzer.c buzzer.h key.c key.h led.c led.h interrupt.c interrupt.h pwm.c pwm.h usart.c usart.h kqm.c kqm.h su_03t.c su_03t.h dht11.c dht11.h ADC.c ADC.h bsp_lcd.c bsp_lcd.h font.h my_lcd.c my_lcd.h photos1.c photos2.c myi2c.c myi2c.h my_spi_flash.c my_spi_flash.h esp8266.c esp8266.h my_mqtt.c my_mqtt.h myrtos.c myrtos.h
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    D:/信盈达环境搭建/MCU/库函数/库函数/lib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group system
    ../System/: Delay.c Delay.h timer.c timer.h MyDMA.c MyDMA.h RTC.c RTC.h
  group photos
    ../user/photos/: 1.c 2.c 4.c 5.c 7.c 8.c 9.c 10.c 11.c 12.c 3.c 6.c
  group mqtt_src
    ../MQTT/: CMakeLists.txt MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group FreeRTOS_core
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_port
    ../FreeRTOS/port/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/port/MemMang/: heap_4.c
  group Cjson
    ../Cjson/: cJSON.c cJSON.h
software components: CMSIS:CORE 5.2.0
